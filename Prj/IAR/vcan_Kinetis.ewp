# IAR project vcan_Kinetis.ewp, settings and files
configuration MK66FX18_Debug (ARM, debug)
  General.OGChipSelectEditMenu: MK66FX1M0xxx18 Freescale MK66FX1M0xxx18
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: DEBUG_MODE; ARM_MATH_CM4; MK66F18; MK66FX18; FPU_USED
  ICCARM.CCIncludePath2: ..\..\App; ..\..\Board\Inc; ..\..\Chip\inc; ..\..\Chip\inc\IAR; ..\..\Chip\inc\kinetis; ..\..\Lib\CMSIS\Inc; ..\..\Lib\FatFs; ..\..\Lib\USB; ..\..; ..\..\App\inc; ..\..\App\user\inc
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: vcan_Kinetis.bin
  ILINK.IlinkOutputFile: vcan_Kinetis.out
  ILINK.IlinkIcfFile: config files\vcan_ROM_K66X1M.icf
  ILINK.IlinkAdditionalLibs: ..\..\Lib\CMSIS\iar_cortexM4l_math.a
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration MK66FX18_Release (ARM)
  as the first configuration, except:
  General.OGChipSelectEditMenu: MK60FN1M0xxx15 Freescale MK60FN1M0xxx15
  General.FPU2: 0
  ICCARM.CCDefines: NDEBUG; ARM_MATH_CM4; MK66F18; MK66FX18; FPU_USED
  ICCARM.CCIncludePath2: ..\..\App; ..\..\App\Inc; ..\..\Board\Inc; ..\..\Chip\inc; ..\..\Chip\inc\IAR; ..\..\Chip\inc\kinetis; ..\..\Lib\CMSIS\Inc; ..\..\Lib\FatFs; ..\..\Lib\USB
  ICCARM.CCOptLevel: 3
  OBJCOPY.OOCOutputFile: vcan_Kinetis.srec
  group App
    ../../App/: main.c
  group App/inc
    ../../App/: enter.h
    ../../App/inc/: MK66_conf.h MK66_it.h PORT_cfg.h
  group App/src
    ../../App/: MK66_conf.c MK66_it.c
  group App/user/inc
    ../../App/user/inc/: buffer.h interrupt.h msg.h msg_format.h queue.h rfid_type.h user.h
  group App/user/src
    ../../App/user/src/: buffer.c interrupt.c msg.c msg_format.c queue.c user.c
  group Board
    ../../Board/src/: VCAN_BMP.c VCAN_computer.c vcan_img2sd.c VCAN_key.c VCAN_key_event.c VCAN_LCD_ILI9325.c VCAN_LCD_ILI9341.c VCAN_LCD_ST7735R.c VCAN_LCD_ST7735S.c VCAN_LED.C VCAN_MMA7455.c VCAN_NRF24L0.c VCAN_NRF24L0_MSG.c VCAN_OV7725_Eagle.c VCAN_RTC_count.C VCAN_SCCB.c vcan_sd_app.c Vcan_touch.c VCAN_TSL1401.c VCAN_UI_VAR.c
  group Chip
    ../../Chip/inc/: common.h
    ../../Chip/src/: misc.c MK66_adc.c MK66_dma.c MK66_flexbus.c MK66_gpio.c MK66_i2c.c MK66_port.c MK66_rtc.c MK66_sdhc.c MK66_spi.c MK66_uart.c MK66_wdog.c vectors.c
    ../../Chip/src/IAR/: startup_MK66FX18.s system_MK66FX18.c
  group LIB/FatFs
    ../../Lib/FatFs/: diskio.c ff.c
